# Keil uVision project Mach_Kich_Hoat_No_Tu.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Mach_Kich_Hoat_No_Tu +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Mach_Kich_Hoat_No_Tu.c main.c
