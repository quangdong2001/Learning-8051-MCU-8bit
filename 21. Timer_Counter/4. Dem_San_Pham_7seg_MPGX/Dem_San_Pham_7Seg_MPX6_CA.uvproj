# Keil uVision project Dem_San_Pham_7Seg_MPX6_CA.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Dem_San_Pham_7Seg_MPX6_CA +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
