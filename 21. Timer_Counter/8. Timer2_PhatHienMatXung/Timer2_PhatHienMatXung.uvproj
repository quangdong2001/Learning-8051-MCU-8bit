# Keil uVision project Timer2_PhatHienMatXung.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Timer2_PhatHienMatXung +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: ru
  group Source Group 1
    ./: main.c
