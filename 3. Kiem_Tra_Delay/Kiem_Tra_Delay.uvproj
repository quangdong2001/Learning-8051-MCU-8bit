# Keil uVision project Kiem_Tra_Delay.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Kiem_Tra_Delay +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Kiem_Tra_Delay.c main.c
