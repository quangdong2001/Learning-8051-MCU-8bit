#include <regx52.h>
#define MATRIX P3

unsigned char code cot[]= { 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80 };
													// {0x80, 0x40, 0x20, 0x10, 0x08, 0x04,0x02, 0x01};
unsigned char code Data[] = {
															0xFF,	0xFF, 0xFF,	0xFF, 0xFF,	0xFF, 0xFF,	0xFF,
	
	
															//0xFF, 0xFF, 0xFC, 0x00, 0x80, 0xCC, 0xEF, 0xFF,
															0xFF, 0xEF, 0xCC, 0x80, 0x00, 0xFC, 0xFF, 0xFF,
	
															0xFF,	0xFF, 0xFF,	0xFF, 0xFF,	0xFF, 0xFF,	0xFF, 
														};







void Sleep_ms(unsigned int t)
{
	unsigned int i,j;
	for(i = 0; i < t; i++)
	{
		for(j = 0; j < 123; j++);
	}
}


void Move_ONE()
{
	while(1)
	{
		unsigned int i,j,k;
		for(i = 0; i < 16; i++)
		{
			for(k = 0 ; k < 20; k++)
			{
				for(j = 0; j < 8; j++)
				{
					MATRIX = ~Data[i+j];
					P0 = cot[j];
					Sleep_ms(1);
					P0 = 0x00;
				}
			}
		}
	
	}
}

	


void main()
{
	Move_ONE();
}
	